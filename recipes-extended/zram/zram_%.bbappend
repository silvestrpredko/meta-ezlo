INITSCRIPT_PARAMS = "start 25 2 3 4 5 . stop 22 0 1 6 ."
