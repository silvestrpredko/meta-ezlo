PACKAGECONFIG_remove = " glamor"
