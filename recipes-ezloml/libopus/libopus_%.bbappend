EXTRA_OECONF_append = " --enable-static" 
