EXTRA_OECONF_append = " --enable-nasm --enable-static" 
