PACKAGECONFIG_remove = "wayland"
