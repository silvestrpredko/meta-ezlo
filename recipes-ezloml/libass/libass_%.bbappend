EXTRA_OECONF_append = " --disable-shared --enable-static" 
