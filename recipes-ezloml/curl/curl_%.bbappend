#PACKAGECONFIG[ssl] = ""

#EXTRA_OECONF += " \
#    --with-ssl=${STAGING_DIR_TARGET}/${libdir}/boringssl \
#    --disable-shared \
#    --enable-static \
#"

