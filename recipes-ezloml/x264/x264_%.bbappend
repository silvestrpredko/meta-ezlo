EXTRA_OECONF_append = " --enable-static -disable-shared --disable-opencl --enable-pic" 

