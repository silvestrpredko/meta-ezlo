EXTRA_OECONF_append = " --disable-examples --enable-static"
