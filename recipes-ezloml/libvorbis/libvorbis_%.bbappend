EXTRA_OECONF_append = " --enable-static --disable-shared" 
